# Keil uVision project u-boot.uvproj, settings and files
target Simulator (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: Blinky
  c flags: Optim=4
  asm define: RAM_INTVEC
  asm misc: --pd "__RTX SETA 1"
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x31000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group cpu
    ../cpu/arm920t/: cpu.c start.S
    ../cpu/arm920t/s3c24x0/: interrupts.c
  group board
    ../board/fl2440/: fl2440.c flash.c nand_read.c fl2440_led.c
  group common
    ../common/: env_common.c env_flash.c environment.c
  group lib_arm
    ../lib_arm/: board.c
  group drives
    ../drivers/mtd/nand/: nand.c nand_base.c
target S3C2440 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: u-boot.axf +hex
  c flags: Optim=4
  c include: .\include
  memory RVCT1: ROM 0x33f80000 size 0x349c
  memory RVCT6: RAM 0x33f8349c size 0x1000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\RuninRAM.sct
